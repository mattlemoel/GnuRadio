options:
  parameters:
    description: Kiwi/Kikiwi telemetry FM front-end
    generate_options: no_gui
    id: kiwi_fm_rx
    output_language: python
    title: Kiwi FM RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 137.950e6
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: nbfm_bw
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate // (nbfm_bw * 8))
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: sync
  id: variable
  parameters:
    value: '''unknown_pps'''
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''''''
    bb_gain0: '20'
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, nbfm_bw, nbfm_bw/4)
    type: ccc
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: chan_rate / (2*3.14159*2500)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(chan_rate)
    interp: int(audio_rate)
    type: fff
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: kiwi_audio.wav
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}

connections:
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.1.1
